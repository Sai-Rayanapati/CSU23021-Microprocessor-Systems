# Keil uVision project SampleLPC2138Project.uvproj, settings and files
target Target (5050169::V5.05 update 2 (build 169)::.\ARMCC_505u2)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SampleLPC2138Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  link misc: --entry=0x00000000 --diag_suppress=L6314
  group Sources
    ./: Startup.s TCD.s
  group Documents
    ./: README.txt
